# Keil uVision project EVBoard_wakeup.uvprojx, settings and files
target projectgroup (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32L373PS MindMotion
  pack: MindMotion.MM32L3xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EVBOUT +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\Device\CMSIS\KEIL_CORE;..\..\..\..\..\Device\MM32L3xx\HAL_lib\inc;..\..\..\..\..\Device\MM32L3xx\Include;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\uart;..\HARDWARE\LED;..\HARDWARE\LCDC;..\HARDWARE\WKUP;..\..\..\..\..\Device\MM32L3xx;..\..\..\..\..\Device\CMSIS\KEIL_CORE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../../../../Device/MM32L3xx/Source/: system_MM32L3xx.c
    ../../../../../Device/MM32L3xx/Source/KEIL_StartAsm/: startup_MM32L3xx.s
  group HALlib
    ../../../../../Device/MM32L3xx/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_crc.c HAL_dac.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_wwdg.c HAL_aes.c
  group USER
    ../USER/: main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/uart/: uart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCDC/: lcdc.c
    ../HARDWARE/WKUP/: wkup.c
  group README
    ../: README.TXT
