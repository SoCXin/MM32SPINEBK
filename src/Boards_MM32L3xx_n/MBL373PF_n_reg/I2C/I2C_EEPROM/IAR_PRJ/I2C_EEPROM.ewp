# IAR project I2C_EEPROM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F103xB MM MM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_IAR
  ICCARM.CCIncludePath2: ..\..\..\..\..\Device\MM32L3xx\Include; ..\SYSTEM\delay; ..\SYSTEM\sys; ..\SYSTEM\uart; ..\HARDWARE\I2C; ..\HARDWARE\LED
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_EEPROM.srec
  ILINK.IlinkOutputFile: output.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group HARDWARE
    ../HARDWARE/I2C/: i2c.c
    ../HARDWARE/LED/: led.c
  group STARTUP
    ../../../../../Device/MM32L3xx/Source/IAR_StartAsm/: startup_MM32L3xx.s
    ../../../../../Device/MM32L3xx/Source/: system_MM32L3xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/uart/: uart.c
  group USER
    ../USER/: test.c
