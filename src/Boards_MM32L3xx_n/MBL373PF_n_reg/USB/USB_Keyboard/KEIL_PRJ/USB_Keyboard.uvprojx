# Keil uVision project USB_Keyboard.uvprojx, settings and files
target MM32L373 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32L373PF MindMotion
  pack: MindMotion.MM32L3xx_DFP.1.0.1
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\bsp;..\bsp\test;..\bsp\usblib;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\uart;..\..\..\..\..\Device\MM32L3xx\Include;..\HARDWARE\KEY;..\..\..\..\..\Device\CMSIS\KEIL_CORE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../../../../Device/MM32L3xx/Source/: system_MM32L3xx.c
    ../../../../../Device/MM32L3xx/Source/KEIL_StartAsm/: startup_MM32L3xx.s
  group USER
    ../bsp/test/: main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/uart/: uart.c
  group bsp
    ../bsp/test/: usbapp.c
    ../HARDWARE/KEY/: key.c
  group usbapp
    ../bsp/usblib/: bulkitem.c bulkusb.c ctrlitem.c ctrlusb.c usbreg.c
  group README
    ../: README.TXT
