# IAR project Backup of USB_Keyboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F103xB MM MM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_IAR
  ICCARM.CCIncludePath2: ..\SYSTEM\delay; ..\SYSTEM\sys; ..\SYSTEM\uart; ..\..\..\..\..\Device\MM32x103\Include; ..\..\..\..\..\Device\MM32x103\HAL_lib\inc; ..\HARDWARE\KEY; ..\bsp; ..\bsp\usblib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: MB103C.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../Device/MM32x103/Source/IAR_StartAsm/: startup_mm32f10x_md.s
    ../../../../../Device/MM32x103/Source/: system_MM32x103.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/uart/: uart.c
  group usbapp
    ../bsp/usblib/: bulkitem.c bulkusb.c ctrlitem.c ctrlusb.c usbreg.c
  group USER
    ../HARDWARE/KEY/: key.c
    ../bsp/test/: main.c usbapp.c
