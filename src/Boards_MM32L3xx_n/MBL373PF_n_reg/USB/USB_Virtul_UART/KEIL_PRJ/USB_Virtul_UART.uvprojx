# Keil uVision project USB_Virtul_UART.uvprojx, settings and files
target MM32L373 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32L373PF MindMotion
  pack: MindMotion.MM32L3xx_DFP.1.0.1
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1
  c include: ..\bsp\test;..\bsp\usblib;..\bsp;..\SYSTEM\delay;..\SYSTEM\uart;..\SYSTEM\sys;..\..\..\..\..\Device\MM32L3xx\Include;..\..\..\..\..\Device\CMSIS\KEIL_CORE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../../../../Device/MM32L3xx/Source/: system_MM32L3xx.c
    ../../../../../Device/MM32L3xx/Source/KEIL_StartAsm/: startup_MM32L3xx.s
  group USER
    ../bsp/test/: main.c
  group SYSTEM
    ../SYSTEM/uart/: uart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group bsp
    ../bsp/test/: usbapp.c
  group usbdriver
    ../bsp/usblib/: ctrlitem.c ctrlusb.c usbreg.c usbprop.c
  group README
    ../: README.TXT
software components: CMSIS:CORE 4.1.0
