# Keil uVision project UART_Receive_DMA_Interrupt.uvprojx, settings and files
target MM32L373 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32L373PF MindMotion
  pack: MindMotion.MM32L3xx_DFP.1.0.1
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\uart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\DMA;..\..\..\..\..\Device\MM32L3xx\Include;..\..\..\..\..\Device\CMSIS\KEIL_CORE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../../../../Device/MM32L3xx/Source/: system_MM32L3xx.c
    ../../../../../Device/MM32L3xx/Source/KEIL_StartAsm/: startup_MM32L3xx.s
  group USER
    ../USER/: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/uart/: uart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DMA/: dma.c
  group README
    ../: README.TXT
