# Keil uVision project USB_VCOM.uvprojx, settings and files
target MM32L373 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32L373PF MindMotion
  pack: MindMotion.MM32L3xx_DFP.1.0.6
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1
  c include: ..\..\..\..\..\Device\CMSIS\KEIL_CORE;..\..\..\..\..\Device\MM32L3xx\HAL_lib\inc;..\..\..\..\..\Device\MM32L3xx\Include;..\bsp\usblib;..\bsp;..\SYSTEM\delay;..\SYSTEM\uart;..\SYSTEM\sys;..\bsp\test;..\HARDWARE\UART;..\bsp\usblib
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../../../../Device/MM32L3xx/Source/: system_MM32L3xx.c
    ../../../../../Device/MM32L3xx/Source/KEIL_StartAsm/: startup_MM32L3xx.s
  group HALlib
    ../../../../../Device/MM32L3xx/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_crc.c HAL_dac.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_tim.c HAL_uart.c HAL_wwdg.c HAL_aes.c
  group USER
    ../bsp/test/: main.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/UART/: uart_usb.c
  group BSP
    ../bsp/test/: usbapp.c
  group usbdriver
    ../bsp/usblib/: ctrlitem.c ctrlusb.c usbreg.c usbprop.c
  group README
    ../: README.TXT
software components: CMSIS:CORE 4.1.0
