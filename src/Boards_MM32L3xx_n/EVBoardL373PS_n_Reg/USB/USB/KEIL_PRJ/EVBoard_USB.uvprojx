# Keil uVision project EVBoard_USB.uvprojx, settings and files
target projectgroup (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32L373PS MindMotion
  pack: MindMotion.MM32L3xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EVBOUT +hex
  c flags: Optim=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\uart;..\USER;..\HARDWARE\usblib;..\HARDWARE\bsp;..\HARDWARE\bsp\test;..\..\..\..\..\Device\MM32L3xx\HAL_lib\inc;..\..\..\..\..\Device\MM32L3xx\HAL_lib\src;..\..\..\..\..\Device\MM32L3xx\Include;..\..\..\..\..\Device\MM32L3xx\Source\KEIL_StartAsm;..\..\..\..\..\Device\CMSIS\KEIL_CORE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../../../../Device/MM32L3xx/Source/: system_MM32L3xx.c
    ../../../../../Device/MM32L3xx/Source/KEIL_StartAsm/: startup_MM32L3xx.s
  group USER
    ../USER/: main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/uart/: uart.c
  group HARDWARE
    ../HARDWARE/bsp/test/: usbapp.c
  group USB
    ../HARDWARE/usblib/: bulkitem.c bulkusb.c ctrlitem.c ctrlusb.c usbreg.c
  group RAEDME
    ../: README.TXT
