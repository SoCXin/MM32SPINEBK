# IAR project EVBoard_FLASH_simulate_EEPROM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32L373PS MM MM32L373PS
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_IAR
  ICCARM.CCIncludePath2: ..\HARDWARE\LED; ..\SYSTEM\delay; ..\SYSTEM\sys; ..\SYSTEM\uart; ..\..\..\..\..\Device\MM32L3xx\Include; ..\HARDWARE\LCDC; ..\HARDWARE\KEY; ..\HARDWARE\WRFLASH
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EVBOUT.srec
  ILINK.IlinkOutputFile: EVBOUT.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCDC/: lcdc.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/WRFLASH/: wrflash.c
  group STARTUP
    ../../../../../Device/MM32L3xx/Source/IAR_StartAsm/: startup_MM32L3xx.s
    ../../../../../Device/MM32L3xx/Source/: system_MM32L3xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/uart/: uart.c
  group USER
    ../USER/: main.c
